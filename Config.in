## Config.in
```kconfig
config BR2_PACKAGE_PYTHON_SLOWAES
    bool "python-slowaes"
    help
      AES in pure python. Slow as Christmas, but it works.
```
